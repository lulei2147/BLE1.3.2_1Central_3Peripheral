<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SimpleBLECentral.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\SimpleBLEPeripheral\CC2541DB\SimpleBLEPeripheral.ewp</path>
  </project>
  <batchBuild/>
</workspace>


